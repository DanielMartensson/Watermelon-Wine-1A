
PACKAGE_INSTALL += " \
    initramfs-module-udev-mmc-fixup \
"
