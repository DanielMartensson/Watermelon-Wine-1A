FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append += "file://0001-Add-log-console-output-for-u-boot.patch"
