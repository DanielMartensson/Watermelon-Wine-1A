SUMMARY = "Multimedia packagegroup for Watermelon Wine 1A"
LICENSE = "MIT"
inherit packagegroup

RDEPENDS:${PN} = " \
	imtube \
"
