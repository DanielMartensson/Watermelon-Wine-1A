SRC_URI += "file://partprobe.cfg"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
